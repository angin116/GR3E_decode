# Keil uVision project GR3E_decode.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C58 SST
  cpu: IRAM(0-0xFF) IROM(0-0x7FFF) CLOCK(33000000)
  output: GR3E_decode +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
